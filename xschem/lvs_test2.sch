v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {devices/iopin.sym} 120 -50 0 1 {name=p5 lab=S}
C {devices/iopin.sym} 80 -80 0 1 {name=p7 lab=G}
C {devices/iopin.sym} 120 -110 0 1 {name=p6 lab=D}
C {devices/iopin.sym} 120 -80 0 0 {name=p11 lab=B}
C {sg13g2_pr/sg13_lv_nmos.sym} 100 -80 0 0 {name=M1
l=0.3u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
