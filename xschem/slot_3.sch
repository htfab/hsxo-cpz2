v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 550 -270 650 -270 {lab=vss_3v3}
C {devices/iopin.sym} 490 -470 0 1 {name=p32 lab=vdd_1v2}
C {devices/iopin.sym} 450 -270 0 1 {name=p33 lab=vss_1v2}
C {devices/iopin.sym} 610 -470 0 0 {name=p34 lab=vdd_3v3}
C {devices/ipin.sym} 380 -390 0 0 {name=p36 lab=dig_in[0]}
C {devices/ipin.sym} 380 -370 0 0 {name=p37 lab=dig_in[1]}
C {devices/ipin.sym} 380 -330 0 0 {name=p38 lab=s3_an_0_esd}
C {devices/opin.sym} 720 -330 0 0 {name=p39 lab=s3_an[1]}
C {devices/opin.sym} 720 -350 0 0 {name=p40 lab=dig_out[0]}
C {devices/ipin.sym} 380 -430 0 0 {name=p41 lab=ibias0}
C {sg13cmos5l_ht_ip__hsxo_cpz2.sym} 550 -370 0 0 {name=X1}
C {devices/iopin.sym} 650 -270 0 0 {name=p1 lab=vss_3v3}
